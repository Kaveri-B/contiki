<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\contiki.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>contiki_build</name>
      <member>
        <project>contiki</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


