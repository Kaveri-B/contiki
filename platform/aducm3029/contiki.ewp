# IAR project contiki.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NETSTACK_CONF_WITH_IPV6; AUTOSTART_ENABLE; RPL_CONF_DAO_ACK; LLSEC_DISABLE; ADI_IAR; ADCM3029_EZKIT_USED; xRFMODULE_7242
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\apps\mbedtls_client; ..\..\apps\https-socket; ..\..\core; ..\..\core\lib; ..\..\core\net; ..\..\core\net\ip; ..\..\core\net\phy; ..\..\core\rpl; ..\..\core\mac; ..\..\core\llsec; ..\..\core\ipv6; ..\..\core\ip; ..\..\core\ip64; ..\..\core\rime; ..\..\core\dev; ..\..\cpu\arm\aducm3029; ..\..\cpu\arm\aducm3029\src\services\gpio\; ..\..\cpu\arm\aducm3029\src\drivers\spi; ..\..\cpu\arm\aducm3029\inc; ..\..\cpu\arm\aducm3029\inc\config; ..\..\cpu\arm\aducm3029\inc\sys; ..\..\cpu\arm\aducm3029\inc\services; ..\..\cpu\arm\aducm3029\inc\drivers; ..\..\cpu\arm\aducm3029\inc\ssdd_common; ..\..\Applications-ADuCM302x\UART_CCM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADWiSUNRFModule.hex
  ILINK.IlinkOutputFile: ADWiSUNRFModule.out
  ILINK.IlinkIcfFile: ADuCM3029.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group core/lib
    ../../core/lib/: list.c memb.c random.c
    ./: utest_support.c
  group core/net
    ../../core/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
  group core/net/ip
    ../../core/net/ip/: tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group core/net/ipv6
    ../../core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group core/net/ipv6/multicast
    ../../core/net/ipv6/multicast/: esmrf.c roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group core/net/llsec
    ../../core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group core/net/mac
    ../../core/net/mac/: csma.c frame802154.c framer-802154.c mac.c
    ../../core/net/mac/sicslowmac/: sicslowmac.c
  group core/net/phy
    ../../core/net/phy/: phy.c
  group core/net/rime
    ../../core/net/rime/: rimestats.c
  group core/net/rpl
    ../../core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../core/sys/: autostart.c ctimer.c etimer.c process.c rtimer.c stimer.c timer.c
  group cpu/arm/aducm3029
    ../../cpu/arm/aducm3029/src/drivers/ADF7242/: adf7242.c
    ../../cpu/arm/aducm3029/src/drivers/crc/: adi_crc.c
    ../../cpu/arm/aducm3029/src/drivers/crypto/: adi_crypto.c
    ../../cpu/arm/aducm3029/src/services/dma/: adi_dma.c
    ../../cpu/arm/aducm3029/src/drivers/flash/: adi_flash.c
    ../../cpu/arm/aducm3029/src/services/gpio/: adi_gpio.c
    ../../cpu/arm/aducm3029/src/drivers/i2c/: adi_i2c.c
    ../../cpu/arm/aducm3029/src/services/int/: adi_int.c
    ../../cpu/arm/aducm3029/src/services/pwr/: adi_pwr.c
    ../../cpu/arm/aducm3029/src/drivers/rng/: adi_rng.c
    ../../cpu/arm/aducm3029/src/services/rtc/: adi_rtc.c
    ../../cpu/arm/aducm3029/src/drivers/spi/: adi_spi.c
    ../../cpu/arm/aducm3029/src/services/tmr/: adi_tmr.c
    ../../cpu/arm/aducm3029/src/drivers/uart/: adi_uart.c
    ../../cpu/arm/aducm3029/src/services/wdt/: adi_wdt.c
    ../../cpu/arm/aducm3029/: clock.c event_manager.c hw_tmr.c list_latest.c sw_timer.c timer_service.c
    ../../cpu/arm/aducm3029/src/: PinMux.c startup.c system.c
  group platform/aducm3029
    ./: contiki-aducm3029-main.c
  group RFModule
    ../../Applications-ADuCM302x/Border_Router/: border-router.c
    ../../Applications-ADuCM302x/UART_CCM/: hif_utility.c RF_Module_API_Handler.c uart_handler.c
    ../../Applications-ADuCM302x/udp_server/: udp-server.c
